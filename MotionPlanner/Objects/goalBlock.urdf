Commit message: Setting Up Pybullet
Done

File: MotionPlanner/Objects/goalBlock.urdf (robot description, URDF)
Before this commit: robot simple_cuboid, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=2 2 2; visual box size=2 2 2
